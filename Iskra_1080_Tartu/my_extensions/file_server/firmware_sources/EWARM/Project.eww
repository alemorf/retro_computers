<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Iskra_1080_sd.ewp</path>
  </project>
  <batchBuild />
</workspace>
