����tennis �c�/*
              SARATOV BEST-C COMPILER
                  sgu,fizika-1989
                  kowalenko d.i.



                    prilovenie 1


    w dannom prilovenii pokazan primer ispolxzowaniq sistemy
dlq napisaniq igrowyh ili sistemnyh programm. w otli~ii ot
assemblera programmu na si movno napisatx gorazdo bystree i
s menx{im ~islom o{ibok. odnako, programma napisannaq na si
zanimaet bolx{e pamqti, ~em programma na assemblere, a
sledowatelxno dolx{e rabotaet.

    pered kompilqciej programmy neobhodimo izmenitx parametry
sistemy. a imenno:
 - oblastx dlq skompilirowannoj programmy dolvna bytx
   ne menx{e 3000 bajt.
 - ~islo, opredelqemoe #DEFINE opredelqet na~alo |krannoj
   oblasti. dlq p|wm s pamqtx` 32 kbajta, ono rawno 77C2H, a
   dlq p|wm s pamqtx` 60 kbajt, ono rawno 0E7C2H.
   |to sootwetstwenno 30658 i 59330.
   pered na~alom kompilqcii sleduet wwesti sootwetswu`}ee
   zna~enie.
 - funkciq INKEY() w priwodimoj programme realizuet
   dinami~eskij opros klawiatury. dlq |togo fragment |toj
   funkcii napisan na assemblere. w zawisimosti ot tipa p|wm
   adres |toj funkcii w monitore movet bytx razli~nym:
   0F81BH - w rk-86
   0FEEAH - w mikro{e
   pered kompilqciej w funkcii INKEY() izmenite adres, po
   kotoromu wyzywaetsq podprogramma dinami~eskogo oprosa.

    poprobujte razobratxsq kak rabotaet |ta programma,
usower{enstwowatx ee. wse w wa{ih rukah.

    pered kompilqciej annotaci` k tekstu programmy stiratx
ne nuvno, t.k. ona awtomati~eski budet proignorirowana
traslqtorom.


*/
#DEFINE BEGIN   30658

INT LEV,BASE,RND1,RND2;
CHAR *TEST;

MAIN()
[[
CHAR C;
INT NUMER;
RND1=RND2=1;
WHILE(1)
[[
PUTCHAR('\C');
OUTSTR("strannyj tennis");
OUTSTR("wersiq dlq rk-86");
OUTSTR("igra napisana na *SARATOV BEST-C COMPILER*");
OUTSTR("wyberi urowenx igry (1-9)");
WHILE ((C=INKEY())<'1' ! C>'9')
[[
IF (C==31) RETURN;
RND(1);
]]
PUTCHAR(C);
LEV=1<<(C-'0');
NUMER=6;
WHILE (--NUMER)
[[
CLEAR();
TEST[2]='0'+NUMER;
GAME();
]]]]
]]

CLEAR()
[[
INT NUM;
PUTCHAR('\C');
TEST=BEGIN;
NUM=64;
BASE=0;
WHILE (--NUM) TEST[++BASE]=127;
NUM=24;
WHILE (--NUM)
[[
BASE=BASE+78;
TEST[BASE]=127;
]]
BASE=1872;
NUM=64;
WHILE (--NUM) TEST[++BASE]=127;
]]

OUTSTR(ADDR)
CHAR *ADDR;
[[
WHILE ( *ADDR ) PUTCHAR(*ADDR++);
PUTCHAR('\R');
PUTCHAR('\N');
]]

INKEY()
[[
#ASM
CALL 0F81BH
MOV L,A
MVI H,0
#ENDASM
]]

GAME()
[[
CHAR CODE;
INT COUNT,NUMER,XMEN,MEN,MEN0,MEN1,BALL,VOL,RN,X,Y,VX,VY;
INT GEN;
GEN=MEN0=MEN=COUNT=0;
MEN1=312;
NUMER=6;
XMEN=MEN0;
WHILE(--NUMER)
[[
TEST[XMEN]='#';
XMEN=XMEN+78;
]]
TEST[BALL=(X=RND(62)+1)+(Y=RND(22)+1)*78]='O';
VX=1;
VY=RND(2)*((RND(2)<<1)-1);
VOL=VX+VY*78;
WHILE(1)
[[
IF ((CODE=INKEY())==3) BREAK;
XMEN=RN=0;
IF (CODE==25&MEN!=0)[[RN=-1;--MEN;XMEN=-78;]]
ELSE
IF (CODE==26&MEN!=20)[[RN=1;++MEN;XMEN=78;]]
IF (XMEN!=0)
[[
IF (XMEN<0)
[[
TEST[MEN1]=0;
TEST[MEN0+XMEN]='#';
]]
ELSE [[
TEST[MEN0]=0;
TEST[MEN1+XMEN]='#';
]]
]]
MEN0=MEN0+XMEN;
MEN1=MEN1+XMEN;
IF (GEN)
[[
GEN=0;
X=X+VX;
Y=Y+VY;
IF (X<1)
[[
NUMER=Y+VY;
IF (NUMER<MEN!NUMER>MEN+4) RETURN;
VY=VY+RN;
Y=Y+RN;
]]
NUMER=0;
IF (X<1!X>62)
 [[NUMER=1;VX=-VX;X=X+VX+VX;]]
IF (Y<1!Y>23)
 [[NUMER=1;VY=-VY;Y=Y+VY+VY;]]
IF (NUMER) VOL=VX+VY*78;
TEST[BALL]='.';
TEST[BALL=BALL+VOL]='O';
IF (COUNT==0) COUNT=RND(100)+1;
IF (COUNT) --COUNT;
IF (COUNT==0)
[[
VY=RND(2)*((RND(2)<<1)-1);
IF (RND(4)==1)
VX=1;
ELSE VX=-1;
VOL=VX+VY*78;
]]
]]
ELSE GEN=1;
NUMER=LEV;
WHILE(--NUMER);
]]
]]

RND(MOD)
INT MOD;
[[
INT SOM;
SOM=(7*RND2+3*RND1+12345)>>1;
RND1=RND2;
RND2=SOM;
RETURN SOM%MOD;
]]

�d�