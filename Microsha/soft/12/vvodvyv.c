����paket wwoda/wywoda �r�CHAR *VAL;

OUTDEC( NUM )
INT NUM;
[[
 INT K,ZS;
 CHAR C;
 ZS=0;
 K=10000;
 IF ( NUM<0 )
  [[
   NUM=-NUM;
   PUTCHAR('-');
  ]]
 WHILE ( K>=1 )
  [[
   C=ABS(NUM/K)+'0';
   IF (( C!='0' ) ! ( K==1 ) ! ( ZS ))
    [[
     ZS=1;
     PUTCHAR(C);
    ]]
   NUM=ABS(NUM%K);
   K=K/10;
  ]]
]]
ABS( NUMER )
INT NUMER;
[[
IF ( NUMER<0 ) NUMER=-NUMER;
RETURN NUMER;
]]



OUTSTR ( TEST )
CHAR *TEST;
[[
 INT K;
 K=0;
 WHILE ( TEST[K] )
 PUTCHAR( TEST[K++] );
]]



GETSTR( TEST,NUM )
CHAR TEST[];
INT NUM;
[[
 INT K;
 CHAR L;
 K=0;
 WHILE ((L=GETCHAR())!='\R' )
 [[
  IF (( L==8 ) & ( K!=0 ))
   [[
    --K;
    PUTCHAR(8);
    PUTCHAR(' ');
    PUTCHAR(8);
   ]]
  ELSE IF (( L<32 ) ! ( K>=NUM-1 )) CONTINUE;
  ELSE PUTCHAR(TEST[K++]=L);
 ]]
 TEST[K]=0;
 RETURN K ;
]]

GETDEC( SIN )
CHAR *SIN;
[[
 INT K,MINUS;
 CHAR C;
 VAL=SIN-1;
 K=MINUS=1;
 WHILE ( K )
  [[
   K=0;
   SYMB();
   IF ( *VAL=='+' ) K=1;
   IF ( *VAL=='-' ) [[ K=1;MINUS=-MINUS; ]]
  ]]
  IF (( *VAL<'0' ) ! ( *VAL>'9' )) RETURN 0;
  WHILE (( *VAL>='0' ) & ( *VAL<='9' ))
  [[
   C=*VAL;
   SYMB();
   K=K*10+(C-'0');
  ]]
  IF ( MINUS<0 ) K=-K;
  RETURN K;
]]
SYMB()
[[
 WHILE ( *(++VAL)==32 ) ;
]]

���