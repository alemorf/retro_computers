����piramidki � �/*
            *SARATOV BEST-C COMPILER*
                prilovenie   2

    w dannom prilovenii priweden tekst programmy
"hanojskie piramidki". pered translqciej neobhodimo
izmenitx sootwetstwu`}ie parametry:
1. w tele #DEFINE ~islo opredelqet adres lewogo werhnego
   ugla |krana. dlq p|wm s pamqtx` 32 kbajta ono
   rawno 30658, a s pamqtx` 60 kbajt ono rawno 59330.
2. pered translqciej nuvno zadatx razmer oblasti dlq
   skompilirowannoj programmy ne menx{e 3300 bajt.
*/

#DEFINE RESET 30658

INT NUMER,NU[3];
CHAR *VAL,*BASE;

HANOI(N,X,Y,Z)
INT N,X,Y,Z;
[[
IF (N!=0)
    [[
    HANOI(N-1,X,Z,Y);
    GOTO(X,Y);
    HANOI(N-1,Z,Y,X);
    ]]
]]


MAIN()
[[
CHAR ZEN,LIT[3];
PUTCHAR('\C');
OUTSTR("hanojskie piramidki");
OUTSTR("programma skompilirowana na");
OUTSTR("*SARATOV BEST-C COMPILER*");
ZEN=1;
WHILE(ZEN)
[[
OUTSTR("wwedi ~islo piramidok ( 1-10 )");
GETSTR(LIT,3);
NUMER=GETDEC(LIT);
IF (*VAL==0&NUMER>=1&NUMER<=10)ZEN=0;
ELSE [[ ZEN=1;OUTSTR(" - o{ibka");]]
]]
DRAW();
HANOI(NUMER,0,1,2);
SOUND();
HANOI(NUMER,1,2,0);
SOUND();
HANOI(NUMER,2,0,1);
SOUND();
GETCHAR();
]]

SOUND()
[[
INT NUM;
NUM=100;
WHILE(NUM--) PUTCHAR(7);
]]

DRAW()
[[
INT Y,Z;
INT DAL,CONT;
PUTCHAR('\C');
NU[0]=NUMER;
NU[1]=NU[2]=0;
BASE=RESET;
Y=(Z=23)-NUMER+1;
WHILE(Z>=Y)
[[
DAL=78*Z-NUMER+33-Z;
CONT=Z+Z-Y-Y+1;
WHILE(CONT--) BASE[DAL++]=127;
--Z;
]]
]]

SGN(X)
INT X;
[[
IF (X<0) RETURN -1;
IF (X>0) RETURN 1;
RETURN 0;
]]

ABS(X)
INT X;
[[
IF (X<0) X=-X;
RETURN X;
]]

GOTO(X,Y)
INT X,Y;
[[
INT CONT,F,Z,BEG,END;
CHAR BYF[21];
Z=25-NU[X];
END=Z*78+20*X;
WHILE(--Z)
[[
END=END-78;
BEG=END;
F=20;
WHILE(F--)
[[
BASE[BEG-78]=BASE[BEG];
BASE[BEG++]=0;
]]
]]
--NU[X];
END=END-78;
Z=SGN(Y-X);
F=20*ABS(Y-X);
WHILE(F--)
[[
BEG=END-1;
CONT=21;
WHILE(CONT--)
BYF[20-CONT]=BASE[BEG++];
CONT=21;
BEG=(END=END+Z)-1;
WHILE(CONT--)
BASE[BEG++]=BYF[20-CONT];
]]
Z=24-NU[Y]++;
WHILE(--Z)
[[
BEG=END;
END=END+78;
F=20;
WHILE(F--)
[[
BASE[BEG+78]=BASE[BEG];
BASE[BEG++]=0;
]]
]]
PUTCHAR(7);
]]



OUTSTR ( TEST )
CHAR *TEST;
[[
 WHILE ( *TEST )
 PUTCHAR( *TEST++ );
PUTCHAR('\R');
PUTCHAR('\N');
]]



GETSTR( TEST,NUM )
CHAR TEST[];
INT NUM;
[[
 INT K;
 CHAR L;
 K=0;
 WHILE ((L=GETCHAR())!='\R' )
 [[
  IF (( L==8 ) & ( K!=0 ))
   [[
    --K;
    PUTCHAR(8);
    PUTCHAR(' ');
    PUTCHAR(8);
   ]]
  ELSE IF (( L<32 ) ! ( K>=NUM-1 )) CONTINUE;
  ELSE PUTCHAR(TEST[K++]=L);
 ]]
 TEST[K]=0;
 RETURN K ;
]]

GETDEC( SIN )
CHAR *SIN;
[[
 INT K,MINUS;
 CHAR C;
 VAL=SIN-1;
 K=MINUS=1;
 WHILE ( K )
  [[
   K=0;
   SYMB();
   IF ( *VAL=='+' ) K=1;
   IF ( *VAL=='-' ) [[ K=1;MINUS=-MINUS; ]]
  ]]
  IF (( *VAL<'0' ) ! ( *VAL>'9' )) RETURN 0;
  WHILE (( *VAL>='0' ) & ( *VAL<='9' ))
  [[
   C=*VAL;
   SYMB();
   K=K*10+(C-'0');
  ]]
  IF ( MINUS<0 ) K=-K;
  RETURN K;
]]
SYMB()
[[
 WHILE ( *(++VAL)==32 ) ;
]]

�R�