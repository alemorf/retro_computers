����ferzi �v�/*
             *SARATOV BEST-C COMPILER*
                    prilovenie 3

    dannoe prilovenie sodervit w sebe tekst programmy
'ferzi'. |ta programma proizwodit rasstanowku 8 ferzej
na {ahmatnoj doske, pri uslowii ~toby ni odin ne bil drugogo.
pered translqciej programmy neobhodimo:
1. izmenitx zna~enie tela operatora #DEFINE w sootwetstwii
   s tipom p|wm. dlq p|wm s pamqtx` 60 kbajt zna~enie
   rawno 59330, a dlq p|wm s pamqtx` 32 kbajta - 30658.
2. pered translqciej neobhodimo zadatx oblastx dlq
   skompilirowannoj programmy ne menx{e 3300 bajt.
*/

#DEFINE BEGIN 30658

CHAR POL[8],NUM,EOF,*ADDR,POL0[8],NUM0;
INT BASE;

MAIN()
[[
CHAR RIS,ZONA,WELL,END;
INT FER,ONE,ALL;
PUTCHAR('\C');
ADDR=BEGIN;
CUR(25,24);
OUTSTR("ferzi");
CUR(25,17);
OUTSTR("nomer");
CUR(20,15);
OUTSTR("sdelano popytok");
CUR(19,20);
OUTSTR("wsego popytok");
ZONA=ONE=FER=ALL=POL[0]=POL0[0]=0;
RIS=NUM=EOF=1;
WHILE(EOF)
[[
NUM0=1;
BASE=20*78+ZONA++*20;
IF (ZONA==0) RIS=0;
IF (ZONA>=3) ZONA=0;
END=1;
IF (RIS)
[[
LINE(BASE-1,8,-78,'!');
LINE(BASE+15,8,-78,'!');
LINE(BASE+78,15,1,'-');
LINE(BASE-78*8,15,1,'-');
ONE=8;
WHILE(ONE--) LINE(BASE-78*ONE,8,2,'.');
]]
ONE=0;
WHILE(EOF&END)
    [[
    ++ONE;
    ++ALL;
    DRAW();
    IF ((WELL=CONTROL())==8)
        [[
        PUTCHAR(7);
        PICTURE(++FER,ONE,ALL,ZONA);
        END=0;
        IF (ZONA==0)
            [[
            CUR(18,13);
            OUTSTR("navmi l`bu` klawi{u");
            GETCHAR();
            CUR(18,13);
            ZONA=23;
            WHILE(--ZONA) PUTCHAR(' ');
            ]]
        ]]
    MOVE(WELL);
    ]]
]]
PUTCHAR(7);
PICTURE(++FER,ONE,ALL,ZONA);
CUR(25,13);
OUTSTR("konec");
GETCHAR();
]]

DRAW()
[[
INT VAR;
VAR=NUM;
WHILE(VAR<=NUM0)
    [[
    ADDR[BASE+(VAR-1<<1)-POL0[VAR-1]*78]='.';
    ++VAR;
    ]]
VAR=NUM0;
WHILE(VAR<=NUM)
    [[
    ADDR[BASE+(VAR-1<<1)-(POL0[VAR-1]=POL[VAR-1])*78]
    =POL[VAR-1]+'1';
    ++VAR;
    ]]
NUM0=NUM;
]]

MOVE(WELL)
CHAR WELL;
[[
IF (WELL!=NUM!NUM==8)
    [[
    WHILE(POL[NUM-1]==7)
        IF (NUM!=1) --NUM;
        ELSE [[ EOF=0;POL[NUM-1]=0; ]]
    ++POL[NUM-1];
    RETURN;
    ]]
POL[NUM++]=0;
]]

CONTROL()
[[
CHAR VAR;
INT VX,VY;
VAR=1;
WHILE(VAR<NUM)
    [[
    VX=NUM-VAR;
    VY=ABS(POL[VAR-1]-POL[NUM-1]);
    IF (POL[VAR-1]==POL[NUM-1]!VX==VY) RETURN VAR;
    ++VAR;
    ]]
RETURN NUM;
]]

LINE(DDR,NUM,SME,COD)
CHAR COD;
INT DDR,NUM,SME;
[[
WHILE(NUM--)
    [[
    ADDR[DDR]=COD;
    DDR=DDR+SME;
    ]]
]]
CHAR *VAL;

OUTDEC( NUM )
INT NUM;
[[
 INT K,ZS;
 CHAR C;
 ZS=0;
 K=10000;
 IF ( NUM<0 )
  [[
   NUM=-NUM;
   PUTCHAR('-');
  ]]
 WHILE ( K>=1 )
  [[
   C=ABS(NUM/K)+'0';
   IF (( C!='0' ) ! ( K==1 ) ! ( ZS ))
    [[
     ZS=1;
     PUTCHAR(C);
    ]]
   NUM=ABS(NUM%K);
   K=K/10;
  ]]
PUTCHAR(' ');
PUTCHAR(' ');
PUTCHAR(' ');
]]
ABS( NUMER )
INT NUMER;
[[
IF ( NUMER<0 ) NUMER=-NUMER;
RETURN NUMER;
]]



OUTSTR ( TEST )
CHAR *TEST;
[[
 INT K;
 K=0;
 WHILE ( TEST[K] )
 PUTCHAR( TEST[K++] );
]]

CUR(X,Y)
CHAR X,Y;
[[
PUTCHAR(27);
PUTCHAR('Y');
PUTCHAR(24-Y+' ');
PUTCHAR(X+' ');
]]

PICTURE(FER,ONE,ALL,ZONA)
INT FER,ONE,ALL,ZONA;
[[
--ZONA;
IF (ZONA<0) ZONA=ZONA+3;
CUR(7+20*ZONA,16);
OUTDEC(FER);
CUR(6+20*ZONA,14);
OUTDEC(ONE);
CUR(33,20);
OUTDEC(ALL);
]]

�