����{ifr ��/*
                SARATOV BEST-C COMPILER
                     prilovenie  5

    w dannom prilovenii sodervitsq tekst programmy,
pozwolq`}ej za{ifrowywatx i de{ifrowywatx teksty na russkom
qzyke. dlq za{ifrowki ispolxzuetsq princip kodirowki tekstow,
predlovennyj bolee sta let nazad izwestnym anglijskim
matematikom i pisatelem lx`isem k|rollom. dlq kompilqcii
programmy nuvno ne menx{e 2000 bajt.
    operatory #DEFINE zada`t maksimalxnyj razmer buferow dlq
wwoda parolq i wwoda tekstowogo soob}eniq. zna~eniq tel |tih
operatorow movno warxirowatx w samyh {irokih predelah.
glawnoe, ~toby hwatilo pamqti p|wm.
*/

#DEFINE dlina           64
#DEFINE wwod            1024

MAIN()
[[
CHAR TEXT[wwod],PAROL[dlina],CODE,WORK;
INT NUMER,NUM;
PUTCHAR('\C');
OUTSTR("{ifrator-de{ifrator tekstow");
PUTSTR("programma skompilirowana na SARATOV BEST-C COMPILER");
WHILE(1)
[[
PUTSTR("wyberi revim raboty:");
PUTSTR(" 0 - konec raboty");
PUTSTR(" 1 - {ifrator");
PUTSTR(" 2 - de{ifrator");
CR();
PUTCHAR(' ');
WHILE(1)
    [[
    CODE=GETCHAR();
    IF (CODE>='0'&CODE<='2')
        [[
        PUTCHAR(CODE);
        BREAK;
        ]]
    ]]
IF (CODE=='0') BREAK;
WORK=CODE-'1';
PUTSTR("wwedi parolx");
CR();
NUMER=GETSTR(PAROL,dlina);
IF (NUMER==0) CONTINUE;
NUMER=NUM=0;
WHILE(PAROL[NUMER])
    [[
    IF (PAROL[NUMER]==' ') --NUM;
    ELSE  PAROL[NUM]=PAROL[NUMER]-'`'+1;
    ++NUMER;
    ++NUM;
    ]]
PAROL[NUM]=0;
PUTSTR("wwedi tekst");
CR();
NUMER=GETSTR(TEXT,wwod);
IF (NUMER==0) CONTINUE;
CR();
NUMER=NUM=0;
WHILE(TEXT[NUMER])
    [[
    IF (TEXT[NUMER]==' ') CODE=TEXT[NUMER];
    ELSE
        [[
        IF (WORK) CODE=TEXT[NUMER]-PAROL[NUM]+1;
        ELSE CODE=TEXT[NUMER]-1+PAROL[NUM];
        IF (CODE>'~') CODE=CODE-31;
        IF (CODE<'`') CODE=CODE+31;
        ++NUM;
        IF (PAROL[NUM]==0) NUM=0;
        ]]
    PUTCHAR(CODE);
    ++NUMER;
    ]]
]]
]]

CR()
[[
PUTCHAR('\R');
PUTCHAR('\N');
]]

PUTSTR(ADDR)
CHAR *ADDR;
[[
CR();
OUTSTR(ADDR);
]]

OUTSTR(ADDR)
CHAR *ADDR;
[[
WHILE(*ADDR) PUTCHAR(*ADDR++);
]]

GETSTR( TEST,NUM )
CHAR TEST[];
INT NUM;
[[
 INT K;
 CHAR L;
 K=0;
 WHILE ((L=GETCHAR())!='\R' )
 [[
 IF (L>='@'&L<='^') L=L+32;
  IF (( L==8 ) & ( K!=0 ))
   [[
    --K;
    PUTCHAR(8);
    PUTCHAR(' ');
    PUTCHAR(8);
   ]]
  ELSE IF (((L<'`'!L>'~')&L!=' ')!K>=NUM-1) CONTINUE;
  ELSE PUTCHAR(TEST[K++]=L);
 ]]
 TEST[K]=0;
 RETURN K ;
]]

��